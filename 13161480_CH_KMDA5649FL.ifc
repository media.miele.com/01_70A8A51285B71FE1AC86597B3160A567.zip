Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 60b14f21-3b3c-428a-a5a8-534b00327210, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:45:45+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13161480_CH_KMDA5649FL:26D56497_CH_13161480_KMDA5649FL, (2)
In: Default
Type - Material: <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 620 mm; Height: 198 mm; Depth: 520 mm
Pset_BuildingElementProxyCommon - Reference: 26D56497_CH_13161480_KMDA5649FL; sets with these values: 2
